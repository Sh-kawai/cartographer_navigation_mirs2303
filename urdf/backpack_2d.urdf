Commit message: odometry

File: urdf/backpack_2d.urdf (robot description, URDF)
Before this commit: robot cartographer_backpack_2d, 4 links, 3 joints
Links:
- removed link gps
- removed link imu
Joints:
- removed joint gps_joint
- removed joint imu_joint
